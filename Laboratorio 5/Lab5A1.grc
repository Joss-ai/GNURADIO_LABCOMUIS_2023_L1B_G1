options:
  parameters:
    author: Jose_Algarin_Diego_Palencia
    copyright: UIS
    generate_options: qt_gui
    id: PruebaPAM_L1BG1
    output_language: python
    title: Modulacion PAM L1BG1
  states: {}

blocks:
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud del mensaje
    start: '0'
    step: '100e-3'
    stop: '10'
    value: '1'
  states: {}
- name: D
  id: variable_qtgui_range
  parameters:
    label: Ancho Pulso
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia del mensaje
    start: '0'
    step: '100'
    stop: 10e3
    value: '100'
  states: {}
- name: fs
  id: variable_qtgui_range
  parameters:
    label: Frecuencia pulsos
    start: '0'
    step: '1'
    stop: 10e3
    value: 1e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: Modulacion_PAM_L1BG1_0
  id: Modulacion_PAM_L1BG1
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [Modulacion_PAM_L1BG1_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', Modulacion_PAM_L1BG1_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
