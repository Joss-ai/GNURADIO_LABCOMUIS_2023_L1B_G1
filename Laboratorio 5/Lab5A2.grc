options:
  parameters:
    author: Jose_Algarin_Diego_Palencia
    copyright: UIS
    generate_options: qt_gui
    id: MultiplexPAM
    output_language: python
    title: Multiplexion PAM L5A2
  states: {}

blocks:
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud del mensaje
    start: '0'
    step: '100e-3'
    stop: '10'
    value: '1'
  states: {}
- name: D
  id: variable_qtgui_range
  parameters:
    label: Ancho del pulso
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: D1
  id: variable_qtgui_range
  parameters:
    label: Retardo 1
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: D2
  id: variable_qtgui_range
  parameters:
    label: Retardo 2
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: D3
  id: variable_qtgui_range
  parameters:
    label: Retardo 3
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: D4
  id: variable_qtgui_range
  parameters:
    label: Retardo 4
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: D5
  id: variable_qtgui_range
  parameters:
    label: Seleccionador señal RX
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: fcorte
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de corte
    start: '100'
    step: '100'
    stop: 1e6
    value: '100'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia del mensaje
    start: '0'
    step: '10'
    stop: 10e3
    value: '100'
  states: {}
- name: fs
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de pulsos
    start: '0'
    step: '1'
    stop: 10e3
    value: 1e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: Modulacion_PAM_L1BG1_0
  id: Modulacion_PAM_L1BG1
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: Modulacion_PAM_L1BG1_0_0
  id: Modulacion_PAM_L1BG1
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: Modulacion_PAM_L1BG1_0_1
  id: Modulacion_PAM_L1BG1
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: Modulacion_PAM_L1BG1_0_2
  id: Modulacion_PAM_L1BG1
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: Modulacion_PAM_L1BG1_0_2_0
  id: Modulacion_PAM_L1BG1
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: Modulacion_PAM_L1BG1_1
  id: Modulacion_PAM_L1BG1
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: analog_sig_source_x_3
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: D1
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: D2
    type: float
  states: {}
- name: blocks_delay_2
  id: blocks_delay
  parameters:
    delay: D3
    type: float
  states: {}
- name: blocks_delay_2_0
  id: blocks_delay
  parameters:
    delay: D4
    type: float
  states: {}
- name: blocks_delay_3
  id: blocks_delay
  parameters:
    delay: D5
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.5'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Documentos/Jose_Diego_comu1/Laboratorio 3/26 De Mayo, Diomedes Díaz - Letra Oficial.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: fcorte
    decim: '1'
    gain: '4'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '6'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: 1024*8
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    type: fcc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '50000000'
    gain0: '0'
    samp_rate: samp_rate*2
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Modulacion_PAM_L1BG1_0, '0', blocks_add_xx_0, '0']
- [Modulacion_PAM_L1BG1_0, '0', qtgui_time_sink_x_0, '0']
- [Modulacion_PAM_L1BG1_0_0, '0', blocks_delay_0, '0']
- [Modulacion_PAM_L1BG1_0_1, '0', blocks_delay_1, '0']
- [Modulacion_PAM_L1BG1_0_2, '0', blocks_delay_2, '0']
- [Modulacion_PAM_L1BG1_0_2_0, '0', blocks_multiply_const_vxx_0, '0']
- [Modulacion_PAM_L1BG1_1, '0', low_pass_filter_0, '0']
- [Modulacion_PAM_L1BG1_1, '0', rational_resampler_xxx_0, '0']
- [analog_sig_source_x_0, '0', Modulacion_PAM_L1BG1_0, '0']
- [analog_sig_source_x_1, '0', Modulacion_PAM_L1BG1_0_2, '0']
- [analog_sig_source_x_2, '0', Modulacion_PAM_L1BG1_0_1, '0']
- [analog_sig_source_x_3, '0', Modulacion_PAM_L1BG1_0_0, '0']
- [blocks_add_xx_0, '0', blocks_delay_3, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '5']
- [blocks_delay_0, '0', blocks_add_xx_0, '1']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_1, '0', blocks_add_xx_0, '2']
- [blocks_delay_1, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_2, '0', blocks_add_xx_0, '3']
- [blocks_delay_2, '0', qtgui_time_sink_x_0, '3']
- [blocks_delay_2_0, '0', blocks_add_xx_0, '4']
- [blocks_delay_2_0, '0', qtgui_time_sink_x_0, '4']
- [blocks_delay_3, '0', Modulacion_PAM_L1BG1_1, '0']
- [blocks_delay_3, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_delay_2_0, '0']
- [blocks_wavfile_source_0, '0', Modulacion_PAM_L1BG1_0_2_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_0, '1']
- [rational_resampler_xxx_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
