options:
  parameters:
    author: Jose_Algarin_Diego_Palencia
    generate_options: qt_gui
    id: Lab3B
    output_language: python
    title: Modulador de amplitud
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0.25'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud del mensaje
    start: '0'
    step: '10e-3'
    stop: '500e-3'
    value: '250e-3'
  states: {}
- name: B
  id: variable_qtgui_range
  parameters:
    label: Cambio de banda
    start: '-1'
    step: '2'
    stop: '1'
    value: '1'
  states: {}
- name: Fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia del mensaje
    start: '0'
    step: '100'
    stop: '20000'
    value: 1e3
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del transmisor
    start: '0'
    step: '1'
    stop: '31'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: k
  id: variable_qtgui_range
  parameters:
    label: Conficiente de sensibilidad k
    start: '-4'
    step: '10e-3'
    stop: '4'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.5625e6
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: frecuencia de muestreo
    start: 1e3
    step: 1e3
    stop: 300e3
    value: 200e3
  states: {state: disabled}
- name: EnvolventeCompleja_DSB_0
  id: EnvolventeCompleja_DSB
  parameters:
    Ac: Ac
    ka: '1'
  states: {}
- name: ModuladorAML1BG1_0
  id: ModuladorAML1BG1
  parameters:
    Ac: Ac
    ka: k
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: Fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Documentos/Jose_Diego_comu1/Laboratorio 3/26 De Mayo, Diomedes Díaz - Letra Oficial.wav
    repeat: 'True'
  states: {}
- name: lab3_Abloque_0
  id: lab3_Abloque
  parameters:
    I_vect: '1024'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48000'
    interp: int(samp_rate)
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [EnvolventeCompleja_DSB_0, '0', blocks_complex_to_real_0, '0']
- [EnvolventeCompleja_DSB_0, '0', qtgui_freq_sink_x_0, '0']
- [EnvolventeCompleja_DSB_0, '0', qtgui_time_sink_x_0, '0']
- [EnvolventeCompleja_DSB_0, '0', uhd_usrp_sink_0, '0']
- [ModuladorAML1BG1_0, '0', blocks_complex_to_real_0, '0']
- [ModuladorAML1BG1_0, '0', qtgui_freq_sink_x_0, '0']
- [ModuladorAML1BG1_0, '0', qtgui_time_sink_x_0, '0']
- [ModuladorAML1BG1_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', EnvolventeCompleja_DSB_0, '0']
- [analog_sig_source_x_0, '0', ModuladorAML1BG1_0, '0']
- [blocks_complex_to_real_0, '0', lab3_Abloque_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', EnvolventeCompleja_DSB_0, '0']
- [rational_resampler_xxx_0, '0', ModuladorAML1BG1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
