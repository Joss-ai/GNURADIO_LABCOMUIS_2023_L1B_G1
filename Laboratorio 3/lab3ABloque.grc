options:
  parameters:
    author: Jose_Algarin_Diego_Palencia
    category: '[Modulos_L1BG1]'
    generate_options: hb_qt_gui
    id: lab3_Abloque
    output_language: python
    title: CalculoPotenciasComu1
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: I_vect
  id: parameter
  parameters:
    label: Longitud FFT
    type: intx
    value: '1024'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(2*135115.625)
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: I_vect
    type: float
  states: {}
- name: cmplx2mag2
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: I_vect
  states: {}
- name: fft_lab3A
  id: fft_vxx
  parameters:
    fft_size: I_vect
    forward: 'True'
    shift: 'True'
    type: float
    window: window.blackmanharris(1024)
  states: {}
- name: lg1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: lg2
  id: blocks_nlog10_ff
  parameters:
    k: '30'
    n: '10'
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Potencia
    name: '"Potencia logaritmica (dBW)"'
    type: float
    unit1: (dBW)
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Potencia
    name: '"Potencia logaritmica (dBm)"'
    type: float
    unit1: (dBm)
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Potencia
    name: '"Potencia Lineal W"'
    type: float
    unit1: (W)
  states: {}
- name: sumavector_Lab3A
  id: ModulosEfren_SumaVector
  parameters:
    Param1: I_vect
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', lg1, '0']
- [blocks_multiply_const_vxx_0, '0', lg2, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_number_sink_2, '0']
- [blocks_stream_to_vector_0, '0', fft_lab3A, '0']
- [cmplx2mag2, '0', sumavector_Lab3A, '0']
- [fft_lab3A, '0', cmplx2mag2, '0']
- [lg1, '0', qtgui_number_sink_0, '0']
- [lg2, '0', qtgui_number_sink_1, '0']
- [pad_source_0, '0', blocks_stream_to_vector_0, '0']
- [sumavector_Lab3A, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
